# Keil uVision project soft_uart.uvproj, settings and files
target Target 1 (MCS-51)
  device: EZ-USB FX2LP (CY7C68XXX-X) Cypress
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0xE000-0xE1FF) CLOCK(48000000) MODDP2
  output: soft_uart +hex
  c flags: SizeSpeed=1
  group sources
    ./: main.c serial.c
  group asm
    ./: STARTUP.A51
